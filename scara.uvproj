# Keil uVision project scara.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC834 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: scara +hex
  c flags: Optimize=12 SizeSpeed=1
  c include: .\inc;C:\Program Files (x86)\Keil_v5\C51\INC
  group Source Group 1
    ./src/: accel.c i2c.c joystick.c lcd.c main.c servo.c
